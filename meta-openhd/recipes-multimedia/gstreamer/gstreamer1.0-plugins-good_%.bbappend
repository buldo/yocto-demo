PACKAGECONFIG:append = " qt5"